# Keil uVision project newprj.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F120 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFFF) CLOCK(100000000) MDU_F120
  output: newprj
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 C8051F12x_FIR_Demo.c C8051F120_defs.h FIR_Constants.h si_toolchain.h stdbool.h stdint.h modbus.h modbus.c F120_FlashPrimitives.c F120_FlashPrimitives.h F120_FlashUtils.h F120_FlashUtils.c fir.c fir.h freqs.h
